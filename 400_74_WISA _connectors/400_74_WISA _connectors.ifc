Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2015-03-26T12:19:40
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20140709_2115(x64) - Exporter 2014.0.2014.0709 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 26 12:19:40 2015 * Host: PC-ARN-001 * Database: C:\Users\mdegans\AppData\Local\Temp\{D84A9157-6E0A-47E8-AEA8-99154EACAC41}\ifc * Database version: 5507 * Database creation date: Thu Mar 26 12:19:35 2015 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 26 12:19:36 2015 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 26 12:19:36 2015 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: R:\Revit 2014\02-Te controleren\Bibliotheken\Engels\IFC\400_74_WISA _connectors.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Graphics - Color: 0; Line Pattern: -3000010; Symbol at End 1 Default: no; Line Weight: 1; Symbol at End 2 Default: yes
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: Model Text:Model Text 1
In: Level 1
Graphics - Text: CONNECTORS; Horizontal Align: Left
Dimensions - Depth: 50 mm
Materials and Finishes - Material: WISA zwart
Identity Data - Subcategory: -2000151
Phasing - Phase Created: New Construction
Constraints - Work Plane: Level : Level 1
Pset_BuildingElementProxyCommon - Reference: Model Text 1
Text - Bold: no; Italic: no; Text Font: Arial; Text Size: 600 mm

# IfcBuildingElementProxy: Model Text:Model Text 2
In: Level 1
Identity Data - Subcategory: -2000151
Materials and Finishes - Material: WISA zwart
Phasing - Phase Created: New Construction
Graphics - Horizontal Align: Left; Text: CONNECTORS
Dimensions - Depth: 50 mm
Constraints - Work Plane: Level : Level 1
Pset_BuildingElementProxyCommon - Reference: Model Text 2
Text - Bold: no; Text Font: Arial; Italic: no; Text Size: 400 mm

# IfcBuildingElementProxy: Model Text:Model Text 3 (3)
In: Level 1
Phasing - Phase Created: New Construction
Dimensions - Depth: 50 mm
Identity Data - Subcategory: -2000151
Graphics - Horizontal Align: Left
Materials and Finishes - Material: WISA zwart
Constraints - Work Plane: Level : Level 1
Pset_BuildingElementProxyCommon - Reference: Model Text 3
Text - Text Font: Arial; Text Size: 200 mm; Bold: no; Italic: no
Name (Model Text:...) | Text
Model Text 3 | CONNECTOR
Model Text 3 | FLUSH PIPES
Model Text 3 | FLEXIFON

# IfcFlowTerminal: closet connector_wisa_no 2 white, RSen_52_PIF_UN_closet connector no.2_wisa:closet connector_wisa_no 2 white:3785940
In: Level 1
Type - ElementType: closet connector_wisa_no 2 white; PredefinedType: USERDEFINED; Classification: 3A(52.30) algemeen (verzamelniveau) (UniFormat); Material: RSen_n6_PEXa_white
Identity Data - Mark: 2325; Rsen_C_code_gtin: 8711778047969; Rsen_C_model: Universeel; Rsen_C_code_SfB_table1: 52.30; Rsen_C_type_comments: Manchet; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Rsen_C_code_ETIM: EC011412; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011412&ArtClassVersion=4; Description: Closet connector no. 2 white; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_STABU: 53.31; Type Comments: Closet connector; Assembly Description: algemeen (verzamelniveau); Model: Universal; URL: www.wisa-sanitair.com/nl/7000120210; Rsen_C_code_manufacturer_product: 7000120210; Manufacturer: WISA; Assembly Code: 3A(52.30); Rsen_C_description: Closet connector no. 2 white; Rsen_C_revit_version: 2014
Phasing - Phase Created: New Construction
Dimensions - Size: 110ø-100ø; Rsen_P_c02_diameter: 100 mm; Rsen_C_diameter: 110 mm; Rsen_P_c01_diameter: 110 mm
Mechanical - System Classification: Undefined
Insulation - Overall Size: 110 mmø-100 mmø; Insulation Thickness: 0
Constraints - Offset: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Graphics - Use Annotation Scale: no
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Other - Rsen_C_content_creator: WISA
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_white

# IfcFlowTerminal: closet connector_wisa_no 3 pergamon, RSen_52_PIF_UN_closet connector no.3_wisa:closet connector_wisa_no 3 pergamon:3786138
In: Level 1
Type - ElementType: closet connector_wisa_no 3 pergamon; PredefinedType: USERDEFINED; Classification: 3A(52.30) algemeen (verzamelniveau) (UniFormat); Material: RSen_n6_PEXa_pergamon
Identity Data - Mark: 2327; Manufacturer: WISA; OmniClass Number: 23.45.00.00; Assembly Description: algemeen (verzamelniveau); URL: www.wisa-sanitair.com/nl/7000119929; Rsen_C_description: Manchet no. 3 pergamon; Rsen_C_code_STABU: 53.31; Rsen_C_code_ETIM: EC011412; Rsen_C_model: Universal; Rsen_C_type_comments: Closet connector; Rsen_C_code_manufacturer_gln: 8711778000001; Type Comments: Closet connector; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011412&ArtClassVersion=4; Rsen_C_code_manufacturer_product: 7000119929; Rsen_C_code_gtin: 8711778162822; Model: Universal; Rsen_C_code_SfB_table1: 52.30; Assembly Code: 3A(52.30); OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Description: Manchet no. 3 pergamon; Rsen_C_revit_version: 2014
Phasing - Phase Created: New Construction
Graphics - Use Annotation Scale: no
Mechanical - System Classification: Undefined
Insulation - Insulation Thickness: 0; Overall Size: 110 mmø-110 mmø
Dimensions - Size: 110ø-110ø; Rsen_C_diameter: 110 mm; Rsen_P_c02_diameter: 110 mm; Rsen_P_c01_diameter: 110 mm
Constraints - Offset: 0 mm; Level: Level: Level 1; Host: Level : Level 1
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Other - Rsen_C_content_creator: WISA; country_index: 1
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_pergamon

# IfcFlowTerminal: closet connector_wisa_no 3 white, RSen_52_PIF_UN_closet connector no.3_wisa:closet connector_wisa_no 3 white:3786074
In: Level 1
Type - ElementType: closet connector_wisa_no 3 white; PredefinedType: USERDEFINED; Classification: 3A(52.30) algemeen (verzamelniveau) (UniFormat); Material: RSen_n6_PEXa_white
Constraints - Offset: 0 mm; Level: Level: Level 1; Host: Level : Level 1
Mechanical - System Classification: Undefined
Insulation - Insulation Thickness: 0; Overall Size: 110 mmø-110 mmø
Identity Data - Mark: 2326; Assembly Code: 3A(52.30); Description: Manchet no. 3 white; Type Comments: Closet connector; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011412&ArtClassVersion=4; Rsen_C_code_STABU: 53.31; Rsen_C_code_SfB_table1: 52.30; Rsen_C_type_comments: Closet connector; Model: Universal; Rsen_C_code_manufacturer_product: 7000119920; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_description: Manchet no. 3 wit; Rsen_C_revit_version: 2014; Manufacturer: WISA; Rsen_C_code_gtin: 8711778047907; URL: www.wisa-sanitair.com/nl/70001119920; Rsen_C_code_ETIM: EC011412; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Assembly Description: algemeen (verzamelniveau); OmniClass Number: 23.45.00.00; Rsen_C_model: Universal
Phasing - Phase Created: New Construction
Dimensions - Size: 110ø-110ø; Rsen_P_c02_diameter: 110 mm; Rsen_P_c01_diameter: 110 mm; Rsen_C_diameter: 110 mm
Graphics - Use Annotation Scale: no
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Other - Rsen_C_content_creator: WISA; country_index: 0
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_white

# IfcFlowTerminal: closet connector_wisa_no 3a w white, RSen_52_PIF_UN_closet connector no.3a w_wisa:closet connector_wisa_no 3a w white:3786216
In: Level 1
Type - ElementType: closet connector_wisa_no 3a w white; PredefinedType: USERDEFINED; Classification: 3A(52.30) algemeen (verzamelniveau) (UniFormat); Material: RSen_n6_PEXa_white
Constraints - Level: Level: Level 1; Offset: 0 mm; Host: Level : Level 1
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Identity Data - Mark: 2328; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Rsen_C_code_SfB_table1: 52.30; Rsen_C_description: Manchet no. 3A W; Rsen_C_code_gtin: 8711778012462; Rsen_C_revit_version: 2014; Rsen_C_code_ETIM: EC011412; Rsen_C_type_comments: Closet connector; Assembly Code: 3A(52.30); URL: www.wisa-sanitair.com/nl/8040301003; Manufacturer: WISA; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011412&ArtClassVersion=4; Rsen_C_code_manufacturer_product: 8040301003; OmniClass Number: 23.45.00.00; Rsen_C_code_manufacturer_gln: 8711778000001; Type Comments: Closet connector; Rsen_C_code_STABU: 53.31; Rsen_C_model: Universal; Assembly Description: algemeen (verzamelniveau); Description: Closet connector no. 3A W; Model: Universal
Dimensions - Size: 110ø-100ø; Rsen_C_diameter: 110 mm; Rsen_P_c02_diameter: 100 mm; Rsen_P_c01_diameter: 110 mm
Graphics - Use Annotation Scale: no
Insulation - Insulation Thickness: 0; Overall Size: 110 mmø-100 mmø
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Other - Rsen_C_content_creator: WISA
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_white

# IfcFlowTerminal: closet connector_wisa_no 3b w white, RSen_52_PIF_UN_closet connector no.3b w_wisa:closet connector_wisa_no 3b w white:3786278
In: Level 1
Type - ElementType: closet connector_wisa_no 3b w white; PredefinedType: USERDEFINED; Classification: 3A(52.30) algemeen (verzamelniveau) (UniFormat); Material: RSen_n6_PEXa_white
Dimensions - Size: 110ø-90ø; Rsen_C_diameter: 110 mm; Rsen_P_c01_diameter: 110 mm; Rsen_P_c02_diameter: 90 mm
Constraints - Offset: 0 mm; Level: Level: Level 1; Host: Level : Level 1
Insulation - Overall Size: 110 mmø-90 mmø; Insulation Thickness: 0
Mechanical - System Classification: Undefined
Identity Data - Mark: 2329; Type Comments: Closet connector; URL: www.wisa-sanitair.com/nl/8040305003; Rsen_C_code_SfB_table1: 52.30; Rsen_C_code_manufacturer_product: 8040305003; Rsen_C_code_manufacturer_gln: 8711778000001; Model: Universal; Rsen_C_code_ETIM: EC011412; Manufacturer: WISA; Rsen_C_type_comments: Manchet; Description: Closet connector no. 3B W; Assembly Description: algemeen (verzamelniveau); Rsen_C_code_gtin: 8711778025639; Rsen_C_description: Manchet no. 3B W; Rsen_C_model: Universeel; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011412&ArtClassVersion=4; OmniClass Number: 23.45.00.00; Rsen_C_revit_version: 2014; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Rsen_C_code_STABU: 53.31; Assembly Code: 3A(52.30)
Graphics - Use Annotation Scale: no
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_white
Other - Rsen_C_content_creator: WISA

# IfcFlowTerminal: closet connector_wisa_no 4 w white, RSen_52_PIF_UN_closet connector no.4 w_wisa:closet connector_wisa_no 4 w white:3786448
In: Level 1
Type - ElementType: closet connector_wisa_no 4 w white; PredefinedType: USERDEFINED; Classification: 3A(52.30) algemeen (verzamelniveau) (UniFormat); Material: RSen_n6_PEXa_white
Mechanical - System Classification: Undefined,Hydronic Supply
Graphics - Use Annotation Scale: no
Identity Data - Mark: 2331; Rsen_C_code_gtin: 8711778012479; Manufacturer: WISA; Model: Universal; OmniClass Number: 23.45.00.00; URL: www.wisa-sanitair.com/nl/8040301004; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011412&ArtClassVersion=4; Rsen_C_description: Manchet no. 4 W; Rsen_C_revit_version: 2014; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Rsen_C_type_comments: Manchet; Rsen_C_code_ETIM: EC011412; Description: Closet connector no. 4 W; Rsen_C_model: Universal; Type Comments: Closet connector; Rsen_C_code_STABU: 53.31; Assembly Description: algemeen (verzamelniveau); Rsen_C_code_manufacturer_product: 8040301004; Rsen_C_code_manufacturer_gln: 8711778000001; Assembly Code: 3A(52.30); Rsen_C_code_SfB_table1: 52.30
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0; Overall Size: 125 mmø-110 mmø
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Size: 125ø-110ø; Rsen_P_c02_diameter: 125 mm; Rsen_P_c01_diameter: 110 mm; Rsen_C_diameter: 125 mm
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_white
Other - Rsen_C_content_creator: WISA

# IfcFlowTerminal: closet connector_wisa_no 4 white, RSen_52_PIF_UN_closet connector no.4_wisa:closet connector_wisa_no 4 white:3786394
In: Level 1
Type - ElementType: closet connector_wisa_no 4 white; PredefinedType: USERDEFINED; Classification: 3A(52.30) algemeen (verzamelniveau) (UniFormat); Material: RSen_n6_PEXa_white
Mechanical - System Classification: Undefined
Identity Data - Mark: 2330; Rsen_C_code_ETIM: EC011412; OmniClass Number: 23.45.00.00; Rsen_C_code_STABU: 53.31; Description: Closet connectorno. 4 white; Rsen_C_code_gtin: 8711778047952; Model: Universal; Rsen_C_code_manufacturer_gln: 8711778000001; Type Comments: Closet connector; Rsen_C_model: Universeel; URL: www.wisa-sanitair.com/nl/7000120200; Rsen_C_description: Manchet no. 4 wit; Rsen_C_type_comments: Closet connector; Rsen_C_code_SfB_table1: 52.30; Manufacturer: WISA; Rsen_C_revit_version: 2014; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011412&ArtClassVersion=4; Rsen_C_code_manufacturer_product: 7000120200; Assembly Description: algemeen (verzamelniveau); Assembly Code: 3A(52.30)
Graphics - Use Annotation Scale: no
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Insulation - Insulation Thickness: 0; Overall Size: 125 mmø-110 mmø
Dimensions - Size: 125ø-110ø; Rsen_P_c01_diameter: 110 mm; Rsen_C_diameter: 125 mm; Rsen_P_c02_diameter: 125 mm
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_white
Other - Rsen_C_content_creator: WISA

# IfcFlowTerminal: closet connector_wisa_no 5 white, RSen_52_PIF_UN_closet connector no.5_wisa:closet connector_wisa_no 5 white:3786565
In: Level 1
Type - ElementType: closet connector_wisa_no 5 white; PredefinedType: USERDEFINED; Classification: 3A(52.30) algemeen (verzamelniveau) (UniFormat); Material: RSen_n6_PEXa_white
Phasing - Phase Created: New Construction
Mechanical - System Classification: Undefined
Graphics - Use Annotation Scale: no
Constraints - Level: Level: Level 1; Host: Level : Level 1; Offset: 0 mm
Identity Data - Mark: 2332; Rsen_C_type_comments: Manchet; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_ETIM: EC011412; Rsen_C_code_manufacturer_product: 7000121940; Rsen_C_code_STABU: 53.31; OmniClass Number: 23.45.00.00; Rsen_C_description: Manchet no. 5 wit; Assembly Code: 3A(52.30); Type Comments: Closet connector; Rsen_C_revit_version: 2014; URL: www.wisa-sanitair.com/nl/7000121940; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011412&ArtClassVersion=4; Rsen_C_model: Universeel; Description: Closet connector no. 5 wihte; Model: Universal; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Assembly Description: algemeen (verzamelniveau); Rsen_C_code_SfB_table1: 52.30; Manufacturer: WISA; Rsen_C_code_gtin: 8711778047990
Insulation - Overall Size: 110 mmø-80 mmø; Insulation Thickness: 0
Dimensions - Size: 110ø-80ø; Rsen_P_c02_diameter: 80 mm; Rsen_C_diameter: 110 mm; Rsen_P_c01_diameter: 110 mm
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_white
Other - Rsen_C_content_creator: WISA

# IfcFlowTerminal: closet connector_wisa_no 6 w white, RSen_52_PIF_UN_closet connector no.6 w_wisa:closet connector_wisa_no 6 w white:3786767
In: Level 1
Type - ElementType: closet connector_wisa_no 6 w white; PredefinedType: USERDEFINED; Classification: 3A(52.30) algemeen (verzamelniveau) (UniFormat); Material: RSen_n6_PEXa_white
Dimensions - Size: 110ø-110ø; Rsen_P_c02_diameter: 110 mm; Rsen_C_diameter: 110 mm; Rsen_P_c01_diameter: 110 mm
Mechanical - System Classification: Undefined
Constraints - Offset: 0 mm; Level: Level: Level 1; Host: Level : Level 1
Insulation - Insulation Thickness: 0; Overall Size: 110 mmø-110 mmø
Identity Data - Mark: 2334; URL: www.wisa-sanitair.com/nl/8040301006; Assembly Description: algemeen (verzamelniveau); Rsen_C_code_manufacturer_product: 8040301006; Rsen_C_model: Universeel; Rsen_C_description: Manchet no. 6 W; Description: Closet connector no. 6 W; Manufacturer: WISA; Rsen_C_code_gtin: 8711778012486; Model: Universal; Rsen_C_code_ETIM: EC011412; Assembly Code: 3A(52.30); Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011412&ArtClassVersion=4; Rsen_C_code_STABU: 53.31; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Type Comments: Closet connector; Rsen_C_revit_version: 2014; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_SfB_table1: 52.30; OmniClass Number: 23.45.00.00; Rsen_C_type_comments: Manchet
Phasing - Phase Created: New Construction
Graphics - Use Annotation Scale: no
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Other - Rsen_C_content_creator: WISA
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_white

# IfcFlowTerminal: closet connector_wisa_no 6 white, RSen_52_PIF_UN_closet connector no.6_wisa:closet connector_wisa_no 6 white:3786629
In: Level 1
Type - ElementType: closet connector_wisa_no 6 white; PredefinedType: USERDEFINED; Classification: 3A(52.30) algemeen (verzamelniveau) (UniFormat); Material: RSen_n6_PEXa_white
Phasing - Phase Created: New Construction
Insulation - Overall Size: 110 mmø-110 mmø; Insulation Thickness: 0
Dimensions - Size: 110ø-110ø; Rsen_C_diameter: 110 mm; Rsen_P_c01_diameter: 110 mm; Rsen_P_c02_diameter: 110 mm
Identity Data - Mark: 2333; Manufacturer: WISA; Assembly Description: algemeen (verzamelniveau); Rsen_C_code_ETIM: EC011412; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Description: Closet connector no. 6 white; Rsen_C_code_manufacturer_product: 7000121580; URL: www.wisa-sanitair.com/nl/7000121580; Rsen_C_model: Universeel; Rsen_C_revit_version: 2014; OmniClass Number: 23.45.00.00; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011412&ArtClassVersion=4; Assembly Code: 3A(52.30); Rsen_C_code_STABU: 53.31; Model: Universal; Rsen_C_description: Manchet no. 6 wit; Type Comments: Closet connector; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_type_comments: Closet connector; Rsen_C_code_SfB_table1: 52.30; Rsen_C_code_gtin: 8711778047983
Mechanical - System Classification: Undefined
Constraints - Level: Level: Level 1; Offset: 0 mm; Host: Level : Level 1
Graphics - Use Annotation Scale: no
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_white
Other - Rsen_C_content_creator: WISA

# IfcFlowTerminal: closet connector_wisa_no 7 w white, RSen_52_PIF_UN_closet connector no.7 w_wisa:closet connector_wisa_no 7 w white:3786932
In: Level 1
Type - ElementType: closet connector_wisa_no 7 w white; PredefinedType: USERDEFINED; Classification: 3A(52.30) algemeen (verzamelniveau) (UniFormat); Material: RSen_n6_PEXa_white
Other - Rsen_C_content_creator: WISA
Dimensions - Rsen_P_c01_diameter: 110 mm; Rsen_C_diameter: 110 mm; Rsen_P_c02_diameter: 110 mm; Size: 110ø-110ø
Identity Data - Assembly Description: algemeen (verzamelniveau); Rsen_C_code_ETIM: EC011412; Model: Universal; Rsen_C_code_STABU: 53.31; Rsen_C_model: Universal; Rsen_C_code_manufacturer_gln: 8711778000001; Description: Closet connector no. 7 W; Rsen_C_description: Manchet no. 7 W; Assembly Code: 3A(52.30); Rsen_C_code_manufacturer_product: 8040301007; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011412&ArtClassVersion=4; Manufacturer: WISA; Rsen_C_code_SfB_table1: 52.30; Rsen_C_revit_version: 2014; Rsen_C_type_comments: Manchet; URL: www.wisa-sanitair.com/nl/8040301007; Rsen_C_code_gtin: 8711778012493; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Type Comments: Closet connector; OmniClass Number: 23.45.00.00; Mark: 2336
Insulation - Overall Size: 110 mmø-110 mmø; Insulation Thickness: 0
Mechanical - System Classification: Undefined
Constraints - Offset: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Graphics - Use Annotation Scale: no
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_white

# IfcFlowTerminal: closet connector_wisa_no 7 white, RSen_52_PIF_UN_closet connector no.7_wisa:closet connector_wisa_no 7 white:3786869
In: Level 1
Type - ElementType: closet connector_wisa_no 7 white; PredefinedType: USERDEFINED; Classification: 3A(52.30) algemeen (verzamelniveau) (UniFormat); Material: RSen_n6_PEXa_white
Graphics - Use Annotation Scale: no
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0; Overall Size: 110 mmø-110 mmø
Mechanical - System Classification: Undefined
Dimensions - Size: 110ø-110ø; Rsen_P_c02_diameter: 110 mm; Rsen_P_c01_diameter: 110 mm; Rsen_C_diameter: 110 mm
Identity Data - Mark: 2335; Type Comments: Closet connector; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Manufacturer: WISA; Rsen_C_revit_version: 2014; Model: Universal; Assembly Code: 3A(52.30); Description: Closet connector no. 7 white; Rsen_C_description: Closet connector no. 7 white; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_SfB_table1: 52.30; OmniClass Number: 23.45.00.00; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011412&ArtClassVersion=4; URL: www.wisa-sanitair.com/nl/7000119910; Assembly Description: algemeen (verzamelniveau); Rsen_C_code_manufacturer_product: 7000119910; Rsen_C_code_ETIM: EC011412; Rsen_C_code_gtin: 8711778047884; Rsen_C_type_comments: Manchet; Rsen_C_code_STABU: 53.31; Rsen_C_model: Universal
Constraints - Host: Level : Level 1; Offset: 0 mm; Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Other - Rsen_C_content_creator: WISA
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_white

# IfcFlowTerminal: closet connector_wisa_no 8 white, RSen_52_PIF_UN_closet connector no.8_wisa:closet connector_wisa_no 8 white:3787017
In: Level 1
Type - ElementType: closet connector_wisa_no 8 white; PredefinedType: USERDEFINED; Classification: 3A(52.30) algemeen (verzamelniveau) (UniFormat); Material: RSen_n6_PEXa_white
Dimensions - Rsen_P_c01_diameter: 110 mm; Rsen_P_c02_diameter: 100 mm; Rsen_C_diameter: 110 mm; Size: 110ø-100ø
Other - Rsen_C_content_creator: WISA
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_white
Identity Data - Rsen_C_code_SfB_table1: 52.30; Rsen_C_code_manufacturer_product: 7000121080; Assembly Description: algemeen (verzamelniveau); Manufacturer: WISA; Model: Universal; Rsen_C_code_gtin: 8711778047976; Type Comments: Closet connector; Rsen_C_model: Universeel; Rsen_C_description: Closet connector no. 8 white; Description: Closet connector no. 8 white; Rsen_C_code_STABU: 53.31; Rsen_C_code_ETIM: EC011412; Assembly Code: 3A(52.30); Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_revit_version: 2014; OmniClass Number: 23.45.00.00; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011412&ArtClassVersion=4; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; URL: www.wisa-sanitair.com/nl/7000121080; Rsen_C_type_comments: Closet connector; Mark: 2337
Mechanical - System Classification: Undefined
Constraints - Level: Level: Level 1; Offset: 0 mm; Host: Level : Level 1
Insulation - Insulation Thickness: 0; Overall Size: 110 mmø-100 mmø
Graphics - Use Annotation Scale: no
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: drain set_wisa_flexifon built in, RSen_52_PIF_UN_drain set flexifon built in_wisa:drain set_wisa_flexifon built in:3793038
In: Level 1
Type - ElementType: drain set_wisa_flexifon built in; PredefinedType: USERDEFINED; Classification: 3A(52.30) algemeen (verzamelniveau) (UniFormat); Material: RSen_n6_PE_black
Materials and Finishes - Rsen_C_material: RSen_n6_PE_black
Other - Rsen_C_content_creator: WISA; calc_flexifon: 70 mm
Dimensions - Rsen_C_diameter: 110 mm; Rsen_P_c01_diameter: 110 mm; flexifon: 0 mm; Size: 110ø
Text - Rsen_P_c01_definition: c01_sewage
Identity Data - URL: www.wisa-sanitair.com/nl/8050390086; Rsen_C_description: Flexifon; Model: Universal; Description: Flexifon; Rsen_C_code_ETIM: EC011597; OmniClass Number: 23.45.00.00; Type Comments: Drain set; Rsen_C_revit_version: 2014; Rsen_C_code_gtin: 8711778139220; Rsen_C_type_comments: Drain set; Rsen_C_model: Universeel; Rsen_C_code_STABU: 53.31; Manufacturer: WISA; Rsen_C_code_SfB_table1: 52.30; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011597&ArtClassVersion=1; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Rsen_C_code_manufacturer_product: 8050390086; Assembly Description: algemeen (verzamelniveau); Rsen_C_code_manufacturer_gln: 8711778000001; Assembly Code: 3A(52.30); Mark: 2344
Mechanical - Rsen_P_c01_fixture units: 0; System Classification: Sanitary
Constraints - Offset: 0 mm; Level: Level: Level 1; Host: Level : Level 1
Insulation - Insulation Thickness: 0; Overall Size: 110 mmø
Phasing - Phase Created: New Construction
Graphics - Use Annotation Scale: no
Mechanical - Flow - Pressure Drop: 0
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: drain set_wisa_flexifon tube, RSen_52_PIF_UN_drain set flexifon tube_wisa:drain set_wisa_flexifon tube:3793146
In: Level 1
Type - ElementType: drain set_wisa_flexifon tube; PredefinedType: USERDEFINED; Classification: 3A(52.30) algemeen (verzamelniveau) (UniFormat); Material: RSen_n6_PEXa_white
Other - Rsen_C_content_creator: WISA; calc_length: 163 mm
Text - Rsen_P_c02_definition: c02_sewage; Rsen_P_c01_definition: c01_sewage
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_white
Mechanical - Rsen_P_c01_fixture units: 0; Rsen_P_c02_fixture units: 0; System Classification: Sanitary
Dimensions - Rsen_C_diameter: 110 mm; Rsen_P_c02_diameter: 110 mm; Rsen_P_c01_diameter: 90 mm; flexifon_length: 100 mm; Size: 90ø-90ø
Identity Data - Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_type_comments: Drain set; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Description: Flexifon; Rsen_C_revit_version: 2014; Type Comments: Drain set; Rsen_C_code_STABU: 53.31; Rsen_C_description: Flexifon; Manufacturer: WISA; Rsen_C_code_manufacturer_product: 1409986087; Rsen_C_code_SfB_table1: 52.30; Assembly Code: 3A(52.30); Rsen_C_code_ETIM: EC011597; Rsen_C_model: Universeel; URL: www.wisa-sanitair.com/nl/1409986087; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011597&ArtClassVersion=1; Assembly Description: algemeen (verzamelniveau); Rsen_C_code_gtin: 8711778108905; OmniClass Number: 23.45.00.00; Model: Universal; Mark: 2345
Graphics - Use Annotation Scale: no
Constraints - Level: Level: Level 1; Offset: 0 mm; Host: Level : Level 1
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0; Overall Size: 90 mmø-90 mmø
Mechanical - Flow - Pressure Drop: 0
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: flush pipe_wisa_pergamon, RSen_52_PIF_UN_flush pipe_wisa:flush pipe_wisa_pergamon:3790268
In: Level 1
Type - ElementType: flush pipe_wisa_pergamon; PredefinedType: USERDEFINED; Classification: 4A(74.22.81) aansluitingen, bijzonder sanitair, ingebouwd (UniFormat); Material: RSen_n6_PEXa_pergamon
Other - Rsen_C_content_creator: WISA
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_pergamon
Dimensions - Rsen_C_diameter: 45 mm
Identity Data - Assembly Description: aansluitingen, bijzonder sanitair, ingebouwd; Rsen_C_code_gtin: 8711778034983; Rsen_C_revit_version: 2014; Rsen_C_code_STABU: 53.31; Rsen_C_model: Universal; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010141&ArtClassVersion=4; URL: www.wisa-sanitair.com/nl/1409111614; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Assembly Code: 4A(74.22.81); Rsen_C_code_ETIM: EC010141; OmniClass Number: 23.45.00.00; Rsen_C_description: Flush pipe 390x350 mm pergamon; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_type_comments: Valpijp; Type Comments: Flush pipe; Model: Universal; Rsen_C_code_SfB_table1: 74.22.81; Manufacturer: WISA; Rsen_C_code_manufacturer_product: 1409111614; Description: Flush pipe 390x350 mm pergamon; Mark: 2343
Constraints - Offset: 0 mm; Moves With Nearby Elements: no; Level: Level: Level 1; Host: Level : Level 1
Insulation - Insulation Thickness: 0
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: flush pipe_wisa_white, RSen_52_PIF_UN_flush pipe_wisa:flush pipe_wisa_white:3790195
In: Level 1
Type - ElementType: flush pipe_wisa_white; PredefinedType: USERDEFINED; Classification: 4A(74.22.81) aansluitingen, bijzonder sanitair, ingebouwd (UniFormat); Material: RSen_n6_PEXa_white
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_white
Dimensions - Rsen_C_diameter: 45 mm
Other - Rsen_C_content_creator: WISA
Identity Data - Assembly Code: 4A(74.22.81); Rsen_C_code_manufacturer_product: 1409111601; Rsen_C_code_STABU: 53.31; Rsen_C_description: Flush pipe 390x350 mm white; Assembly Description: aansluitingen, bijzonder sanitair, ingebouwd; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_SfB_table1: 74.22.81; Rsen_C_code_gtin: 8711778003590; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010141&ArtClassVersion=4; Model: Universal; Rsen_C_type_comments: Valpijp; Rsen_C_code_ETIM: EC010141; Description: Flush pipe 390x350 mm white; OmniClass Number: 23.45.00.00; URL: www.wisa-sanitair.com/nl/1409111601; Rsen_C_model: Universal; Manufacturer: WISA; Rsen_C_revit_version: 2014; Type Comments: Flush pipe; Mark: 2342
Constraints - Offset: 0 mm; Moves With Nearby Elements: no; Level: Level: Level 1; Host: Level : Level 1
Insulation - Insulation Thickness: 0
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: manchet_wisa_no 8 w wit, RSen_52_PIF_UN_closet connector no.8 w_wisa:manchet_wisa_no 8 w wit:3787082
In: Level 1
Type - ElementType: manchet_wisa_no 8 w wit; PredefinedType: USERDEFINED; Classification: 3A(52.30) algemeen (verzamelniveau) (UniFormat); Material: NLRS_n6_PEXa_wit
Materials and Finishes - NLRS_C_materiaal: NLRS_n6_PEXa_wit
Dimensions - Rsen_P_c02_diameter: 100 mm; NLRS_C_diameter: 110 mm; Rsen_P_c01_diameter: 110 mm; Size: 110ø-100ø
Other - NLRS_C_code_fabrikant_product: 8040301008; NLRS_C_content_creator: WISA
Identity Data - NLRS_C_code_fabrikant_gln: 8711778000001; NLRS_C_revit_versie: 2014; Description: Manchet no. 8 W; NLRS_C_description: Manchet no. 8 W; Model: Universeel; NLRS_C_code_SfB_tabel1: 52.30; NLRS_C_code_gtin: 8711778012509; OmniClass Number: 23.45.00.00; NLRS_C_model: Universeel; Assembly Code: 3A(52.30); OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Type Comments: Manchet; Assembly Description: algemeen (verzamelniveau); NLRS_C_code_ETIM: EC011412; Manufacturer: WISA; NLRS_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011412&ArtClassVersion=4; NLRS_C_code_STABU: 53.31; NLRS_C_type_comments: Manchet; URL: www.wisa-sanitair.com/nl/8040301008; Mark: 2338
Mechanical - System Classification: Undefined
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0; Overall Size: 110 mmø-100 mmø
Graphics - Use Annotation Scale: no
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: wall closet bend_wisa_301A, RSen_52_PIF_UN_wall closet bend 301a_wisa:wall closet bend_wisa_301A:3789253
In: Level 1
Type - ElementType: wall closet bend_wisa_301A; PredefinedType: USERDEFINED; Classification: 3A(52.30) algemeen (verzamelniveau) (UniFormat)
Text - Rsen_P_c01_definition: c01_sewage
Other - Rsen_C_content_creator: WISA
Dimensions - Rsen_P_c01_diameter: 110 mm; Rsen_C_diameter: 110 mm; Size: 110ø
Mechanical - Rsen_P_c01_fixture units: 0; System Classification: Sanitary
Identity Data - Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC003024&ArtClassVersion=1; Rsen_C_revit_version: 2014; OmniClass Number: 23.45.00.00; Description: Discharge elbows; Rsen_C_type_comments: Afvoerbocht; Rsen_C_code_ETIM: EC003024; Rsen_C_model: Universeel; Assembly Description: algemeen (verzamelniveau); URL: www.wisa-sanitair.com/nl/7010120220; Rsen_C_code_STABU: 53.31; Rsen_C_code_SfB_table1: 52.30; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Rsen_C_code_gtin: 8711778048188; Rsen_C_description: Afvoerbocht 301A; Type Comments: Discharge elbows 303E; Assembly Code: 3A(52.30); Model: Universal; Manufacturer: WISA; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_manufacturer_product: 7010120220; Mark: 2339
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Insulation - Overall Size: 110 mmø; Insulation Thickness: 0
Mechanical - Flow - Pressure Drop: 0
Phasing - Phase Created: New Construction
Graphics - Use Annotation Scale: no
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: wall closet bend_wisa_303C, RSen_52_PIF_UN_wall closet bend 303c_wisa:wall closet bend_wisa_303C:3789397
In: Level 1
Type - ElementType: wall closet bend_wisa_303C; PredefinedType: USERDEFINED; Classification: 3A(52.30) algemeen (verzamelniveau) (UniFormat)
Text - Rsen_P_c01_definition: c01_sewage
Dimensions - Rsen_P_c01_diameter: 100 mm; Rsen_C_diameter: 100 mm; Size: 100ø
Other - Rsen_C_content_creator: WISA
Mechanical - Rsen_P_c01_fixture units: 0; System Classification: Sanitary
Identity Data - OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Rsen_C_revit_version: 2014; Assembly Code: 3A(52.30); URL: www.wisa-sanitair.com/nl/7010121440; Description: Discharge elbows 301A; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC003024&ArtClassVersion=1; Model: Universal; Rsen_C_code_ETIM: EC003024; Rsen_C_code_manufacturer_product: 7010121440; Rsen_C_code_gtin: 8711778048348; Rsen_C_code_STABU: 53.31; Rsen_C_type_comments: Discharge elbows 303E; Manufacturer: WISA; Rsen_C_model: Universeel; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_description: Afvoerbocht 303C; Type Comments: Discharge elbows 303E; Rsen_C_code_SfB_table1: 52.30; Assembly Description: algemeen (verzamelniveau); Mark: 2340
Phasing - Phase Created: New Construction
Constraints - Host: Level : Level 1; Offset: 0 mm; Level: Level: Level 1
Insulation - Overall Size: 100 mmø; Insulation Thickness: 0
Mechanical - Flow - Pressure Drop: 0
Graphics - Use Annotation Scale: no
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: wall closet bend_wisa_303E, RSen_52_PIF_UN_wall closet bend 303e_wisa:wall closet bend_wisa_303E:3789467
In: Level 1
Type - ElementType: wall closet bend_wisa_303E; PredefinedType: USERDEFINED; Classification: 3A(52.30) algemeen (verzamelniveau) (UniFormat)
Text - Rsen_P_c01_definition: c01_sewage
Dimensions - Rsen_P_c01_diameter: 100 mm; Rsen_C_diameter: 100 mm; Size: 100ø
Mechanical - Rsen_P_c01_fixture units: 0; System Classification: Sanitary
Other - Rsen_C_content_creator: WISA
Identity Data - Rsen_C_code_STABU: 53.31; OmniClass Number: 23.45.00.00; Assembly Code: 3A(52.30); Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC003024&ArtClassVersion=1; Rsen_C_model: Universal; Rsen_C_type_comments: Afvoerbocht; Manufacturer: WISA; Model: Universal; Type Comments: Discharge elbows 303E; Rsen_C_revit_version: 2014; URL: www.wisa-sanitair.com/nl/7010121460; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Rsen_C_code_SfB_table1: 52.30; Description: Discharge elbows 303C; Rsen_C_code_gtin: 8711778048386; Rsen_C_code_manufacturer_product: 7010121460; Assembly Description: algemeen (verzamelniveau); Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_description: Discharge elbows 303C; Rsen_C_code_ETIM: EC003024; Mark: 2341
Insulation - Insulation Thickness: 0; Overall Size: 100 mmø
Phasing - Phase Created: New Construction
Mechanical - Flow - Pressure Drop: 0
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Graphics - Use Annotation Scale: no
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcMember: 74_WISA_logo, 74_WISA_logo:74_WISA_logo:2646220
In: Level 1
Type - ElementType: 74_WISA_logo; Classification:  (UniFormat); Material: WISA blauw
Phasing - Phase Created: New Construction
Constraints - Level: Level: Level 1; Offset: 0 mm; Host: Level : Level 1; Moves With Nearby Elements: no
Dimensions - Volume: 4.01625 ft3
Pset_MemberCommon - Reference: 74_WISA_logo; LoadBearing: yes; IsExternal: no; Span: 50 mm; Slope: 0 deg
